# Keil uVision project project.uvprojx, settings and files
target STM32L053R8_NUCLEO (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: STM32L053R8-Nucleo
  AfterMake: fromelf --bin -o STM32L053R8-Nucleo\STM32L053R8-Nucleo.bin STM32L053R8-Nucleo\STM32L053R8-Nucleo.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L053xx,USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER,
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32L0xx-Nucleo;..\..\..\..\..\..\Drivers\BSP\Components\M24SR;..\..\..\..\..\..\Middlewares\ST\lib_NDEF\inc;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-NFC01A1;..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo;..\..\..\..\..\..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Applications/MDK-ARM
    ./: startup_stm32l053xx.s
  group Applications/User
    ../../Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components/M24SR
    ../../../../../../Drivers/BSP/Components/M24SR/: lib_M24SR.c m24sr.c
  group Drivers/BSP/STM32L0xx-Nucleo
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-NFC01A1
    ../../../../../../Drivers/BSP/X-NUCLEO-NFC01A1/: drv_I2C_M24SR.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c
  group Middlewares
    ../../../../../../Middlewares/ST/lib_NDEF/src/: lib_ISO7816_Password.c lib_NDEF.c lib_NDEF_AAR.c lib_NDEF_Email.c lib_NDEF_Geo.c lib_NDEF_MyApp.c lib_NDEF_SMS.c lib_NDEF_URI.c lib_NDEF_Vcard.c lib_STProprietary_feature.c lib_TagType4.c
