# IAR project project.ewp, settings and files
configuration STM32F302R8-Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F302R8 ST STM32F302R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F302x8; USE_HAL_DRIVER; USE_STM32F3XX_NUCLEO
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ..\..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F3xx-Nucleo; ..\..\..\..\..\..\Drivers\BSP\Components\M24SR; ..\..\..\..\..\..\Middlewares\ST\lib_NDEF\inc; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-NFC01A1; ..\..\..\..\..\..\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F302R8-Nucleo.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f302x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications/EWARM
    ./: startup_stm32f302x8.s
  group Applications/User
    ../../Src/: main.c stm32f3xx_hal_msp.c stm32f3xx_it.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components/M24SR
    ../../../../../../Drivers/BSP/Components/M24SR/: lib_M24SR.c m24sr.c
  group Drivers/BSP/STM32F3xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F3xx-Nucleo/: stm32f3xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-NFC01A1
    ../../../../../../Drivers/BSP/X-NUCLEO-NFC01A1/: drv_I2C_M24SR.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c
  group Middlewares
    ../../../../../../Middlewares/ST/lib_NDEF/src/: lib_ISO7816_Password.c lib_NDEF.c lib_NDEF_AAR.c lib_NDEF_Email.c lib_NDEF_Geo.c lib_NDEF_MyApp.c lib_NDEF_SMS.c lib_NDEF_URI.c lib_NDEF_Vcard.c lib_STProprietary_feature.c lib_TagType4.c
